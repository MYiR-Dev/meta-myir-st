PACKAGECONFIG:append = "linuxfb"

