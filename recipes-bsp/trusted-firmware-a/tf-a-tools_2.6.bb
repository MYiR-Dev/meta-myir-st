require tf-a-myir-common.inc
require tf-a-tools.inc

SUMMARY = "Cert_create & Fiptool for fip generation for Trusted Firmware-A"
LICENSE = "BSD-3-Clause"

# Configure settings
TFA_PLATFORM  = "stm32mp1"
