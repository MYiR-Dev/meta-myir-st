
RDEPENDS:${PN}:remove = "qtwebkit"


